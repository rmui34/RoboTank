# IAR project RoboSlave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pe550, pe144, pa039, pe513
  ICCARM.CCIncludePath2: ; ..\Common\include; ..\..\Source\include; ..\..\..\..\..\..\inc; ..\Common\drivers\LuminaryMicro
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a; ..\Common\drivers\LuminaryMicro\IAR\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: common.c common.h keypad.c keypad.h motor.c TimerHandler.c TimerHandler.h UART.c uart.h
    ../../../../../../inc/: hw_types.h
  group Demo files
    ./: main.c
  group Library files
    ../../../../../../driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    ./: formike128x128x16.c osram128x64x4.c rit128x96x4.c
    ../Common/drivers/LuminaryMicro/IAR/: grlib.a
  group Scheduler files
    ../../Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
