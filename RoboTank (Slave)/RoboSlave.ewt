<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Demo files</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
  <group>
    <name>Library files</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\driverlib\ewarm-cm3\Exe\driverlib-cm3.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\formike128x128x16.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\drivers\LuminaryMicro\IAR\grlib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\osram128x64x4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\rit128x96x4.c</name>
    </file>
  </group>
  <group>
    <name>Scheduler files</name>
    <file>
      <name>$PROJ_DIR$\..\..\Source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM3\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM3\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>System files</name>
    <file>
      <name>$PROJ_DIR$\startup_ewarm.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\common.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\..\inc\hw_types.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\keypad.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\keypad.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\motor.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\TimerHandler.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\TimerHandler.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UART.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\uart.h</name>
  </file>
</project>


